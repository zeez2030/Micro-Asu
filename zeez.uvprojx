# Keil uVision project zeez.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: zeez +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    C:/Embbedded programming/Project 3/: main.c newdelay.c port-init.c sevensegment.c switches.c lm4f120h5qr.h newdelay.h port-init.h sevensegment.h switches.h
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.1
